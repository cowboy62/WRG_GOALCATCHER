# Repository cowboy62/WRG_GOALCATCHER

## KiCad design WRG_GOALCATCHER.kicad_pcb

Parts:
C1, C4: 100u; CP_Radial_D5.0mm_P2.50mm
C2, C3, C10, C15: 22uF; C_0805_2012Metric
C6, C8: 100uf; C_1210_3225Metric
C7, C9, C20, C21, C34: 0.1uf; C_0603_1608Metric
C11, C16: NC; C_1210_3225Metric
C12, C13, C14, C17, C18, C22, C23, C24, C25, C26, C27, C28, C29, C30, C31, C32, C33: 0.1uF; C_0603_1608Metric
D2, D9: SS34; D_SMA
D3, D4, D5, D6, D7, D8, D10, D11: WS2812B; LED_WS2812B_PLCC4_5.0x5.0mm_P3.2mm
FB1: FerriteBead_Small; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
H1: COWWHEEL
H2, H3: WHEEL; Pillars-M3.2R5
H4, H5, H6, H7, H9, H10, H11, H12: ARM; Pillars-M3.2R5
H8: COWWHEEL2; cowWHELL2
J1, J6: Conn_01x03; PinHeader_1x03_P2.54mm_Vertical
J2, J17: Conn_01x02; 2P_aa
J3: Conn_01x04_Male; PinHeader_1x04_P2.54mm_Vertical
J4, J5, J8, J9: Conn_01x03_Pin; PinHeader_1x03_P2.54mm_Vertical
J7, J10, J11, J12: VL6180; PinSocket_1x06_P2.54mm_Vertical
J13, J14: Conn_01x04; lego-moto
L1, L2: 22UH; L_Cenker_CKCS6045
R3, R24: 88K/NULL; R_0603_1608Metric
R4, R5, R6, R7: 100; R_0603_1608Metric
R8, R25: 12K; R_0603_1608Metric
R9, R11, R13, R15, R17, R19, R20, R22, R23: 330R; R_0603_1608Metric
R10, R12, R14, R16, R18, R39, R40: 4.7k; R_0603_1608Metric
R21, R26: 50K; R_0603_1608Metric
R27, R28, R29, R30, R31, R32, R33, R34, R35, R36, R37, R38: 4.7K; R_0603_1608Metric
RV5, RV6: 50K; Potentiometer_Bourns_3214J_Horizontal
SW1, SW2: SW_Push; SW_SPST_Omron_B3F-40xx
SW3, SW4: SW_SPDT; SW_Slide_1P2T_CK_OS102011MS2Q
TC1, TC2, TC3, TC4, TC5, TC6, TC7: TCRT5000; OPTO_TCRT5000; PARTREV 1.7
U1: hub_8735_ultra
U2, U8: 14500_battery_slot
U3, U4: SA8301
U5, U7: charger
U6, U9: MT3608/SX1308; SOT-23-6
U10: ADS1015IDGS; TSSOP-10_3x3mm_P0.5mm
U11: APDS9960; Broadcom_LGA-8_2x2mm_P0.5mm
U12: TCS34725FN; SON65P200X240X70-6N; PARTREV 1-02
U13: TCA9548APWR; TSSOP-24_4.4x7.8mm_P0.65mm

Connections:
+3V3: C20.1, C21.1, C34.1, FB1.1, J3.2, R9.1, R11.1, R13.1, R15.1, R17.1, R19.1, R20.1, R22.1, R23.1, R27.1, R28.1, R29.1, R30.1, R31.1, R32.1, R33.1, R34.1, R35.1, R36.1, R37.1, R38.1, TC1.COLL, TC2.COLL, TC3.COLL, TC4.COLL, TC5.COLL, TC6.COLL, TC7.COLL, U1.32 (3.3V), U11.2 (VDD), U12.1 (VDD), U13.3 (~RESET), U13.24 (VCC)
ADC0: C24.1, R14.2, TC3.E, U1.5 (2)
ADC1: C23.1, R12.2, TC2.E, U1.4 (1)
ADC2: C22.1, R10.2, TC1.E, U1.3 (0)
ADC6: C28.1, R18.2, TC5.E, U1.12 (9)
ADC7: C25.1, R16.2, TC4.E, U1.13 (10)
ADC10: C27.1, R39.2, TC6.E, U10.4 (AIN0)
ADC11: C26.1, R40.2, TC7.E, U10.5 (AIN1)
BATTERY+: C2.1, C13.1, L1.1, SW4.2 (B), SW4.3 (C), U6.4 (EN), U6.5 (IN)
BATTERY-: U2.1 (GND), U5.1 (B-), U5.2 (B-), U5.3 (B-)
GND: C1.2, C2.2, C3.2, C4.2, C6.2, C8.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, C34.2, D3.3 (VSS), D4.3 (VSS), D5.3 (VSS), D6.3 (VSS), D7.3 (VSS), D8.3 (VSS), D10.3 (VSS), D11.3 (VSS), J3.1, J4.3, J5.3, J7.2, J8.3, J9.3, J10.2, J11.2, J12.2, R8.1, R10.1, R12.1, R14.1, R16.1, R18.1, R25.1, R39.1, R40.1, SW1.2, SW2.2, TC1.CATH, TC2.CATH, TC3.CATH, TC4.CATH, TC5.CATH, TC6.CATH, TC7.CATH, U1.2 (GND), U3.6 (AGND), U3.7 (PGND), U4.6 (AGND), U4.7 (PGND), U6.2 (GND), U9.2 (GND), U10.1 (ADDR), U10.3 (GND), U11.3 (GND), U12.3 (GND), U13.1 (A0), U13.2 (A1), U13.12 (GND), U13.21 (A2)
unnamed: D2.2 (A), L1.2, U6.1 (SW)
unnamed: D3.2 (DOUT), D4.4 (DIN)
unnamed: D4.2 (DOUT), D5.4 (DIN)
unnamed: D5.2 (DOUT), D6.4 (DIN)
unnamed: D6.2 (DOUT), D7.4 (DIN)
unnamed: D7.2 (DOUT), D8.4 (DIN)
unnamed: D9.2 (A), L2.2, U9.1 (SW)
unnamed: D8.2 (DOUT), D10.4 (DIN)
unnamed: D10.2 (DOUT), D11.4 (DIN)
unnamed: J4.1, R4.1
unnamed: J5.1, R5.1
unnamed: J8.1, R6.1
unnamed: J9.1, R7.1
unnamed: C7.2, J2.2, J13.1, J13.2, U3.5 (OUTB)
unnamed: C7.1, J2.1, J13.3, J13.4, U3.8 (OUTA)
unnamed: C9.2, J14.1, J14.2, J17.2, U4.5 (OUTB)
unnamed: C9.1, J14.3, J14.4, J17.1, U4.8 (OUTA)
unnamed: R9.2, TC1.A
unnamed: R11.2, TC2.A
unnamed: R13.2, TC3.A
unnamed: R15.2, TC7.A
unnamed: R17.2, TC6.A
unnamed: R21.1, RV5.2, RV5.3
unnamed: R22.2, TC4.A
unnamed: R23.2, TC5.A
unnamed: R26.1, RV6.2, RV6.3
unnamed: SW3.1 (A), U7.4 (B+), U7.5 (B+), U7.6 (B+), U8.0 (VCC)
unnamed: SW4.1 (A), U2.0 (VCC), U5.4 (B+), U5.5 (B+), U5.6 (B+)
unnamed: U5.7 (V+), U5.9 (V+)
unnamed: U5.8 (V-), U5.10 (V-)
unnamed: R3.1, R8.2, RV5.1, U6.3 (FB)
unnamed: U7.7 (V+), U7.9 (V+)
unnamed: U7.8 (V-), U7.10 (V-)
unnamed: U7.1 (B-), U7.2 (B-), U7.3 (B-), U8.1 (GND)
unnamed: R24.1, R25.2, RV6.1, U9.3 (FB)
unnamed: C18.1, FB1.2, U10.8 (VDD)
PWM0: R4.2, U1.23 (19)
PWM1: R5.2, U1.22 (20)
PWM2: U1.21, U3.2 (INA)
PWM5: U1.20 (22), U3.3 (INB)
PWM6: U1.19 (23), U4.2 (INA)
PWM7: U1.18 (24), U4.3 (INB)
PWM8: R7.2, U1.14 (11)
PWM9: R6.2, U1.15 (12)
SCL: J3.3, R28.2, U1.7 (4), U10.10 (SCL), U11.5 (SCL), U13.22 (SCL)
SCL0: R29.2, U12.2 (SCL), U13.5 (SC0)
SCL1: J11.3, R31.2, U13.7 (SC1)
SCL2: J12.3, R33.2, U13.9 (SC2)
SCL3: J10.3, R35.2, U13.11 (SC3)
SCL4: U13.14 (SC4)
SCL5: U13.16 (SC5)
SCL6: U13.18 (SC6)
SCL7: J7.3, R37.2, U13.20 (SC7)
SDA: J3.4, R27.2, U1.6 (3), U10.9 (SDA), U11.6 (SDA), U13.23 (SDA)
SDA0: R30.2, U12.6 (SDA), U13.4 (SD0)
SDA1: J11.4, R32.2, U13.6 (SD1)
SDA2: J12.4, R34.2, U13.8 (SD2)
SDA3: J10.4, R36.2, U13.10 (SD3)
SDA4: U13.13 (SD4)
SDA5: U13.15 (SD5)
SDA6: U13.17 (SD6)
SDA7: J7.4, R38.2, U13.19 (SD7)
SW1: R19.2, SW1.1, U1.27 (16)
SW2: R20.2, SW2.1, U1.11 (8)
VD: C3.1, C14.1, C29.1, C30.1, C31.1, C32.1, C33.1, D3.1 (VDD), D4.1 (VDD), D5.1 (VDD), D6.1 (VDD), D7.1 (VDD), D8.1 (VDD), D10.1 (VDD), D11.1 (VDD), J7.1, J10.1, J11.1, J12.1, L2.1, SW3.2 (B), SW3.3 (C), U9.4 (EN), U9.5 (IN)
VDC: C4.1, C10.1, C11.1, C12.1, D2.1 (K), J1.1, J6.1, R3.2, R21.2
VDD: C1.1, C15.1, C16.1, C17.1, D9.1 (K), J1.3, J6.3, R24.2, R26.2, U1.1 (5V)
VPP: J1.2, J4.2, J5.2, J8.2, J9.2
Vdrive: C6.1, C8.1, J6.2, U3.4 (VDD), U4.4 (VDD)
WS2812: D3.4 (DIN), U1.16 (13)

Notes on the sheet:
OLED
ADDRESS 0x52. 可訂義
address 0x39
i2c地址設需確認
address 0x29

Board: 2 copper layers, 141.9 x 198.0 mm, 134 parts (100 on the bottom side), 75 nets.
